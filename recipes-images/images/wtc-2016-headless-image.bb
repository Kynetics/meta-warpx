require recipes-core/images/core-image-base.bb
require wtc-2016.inc

SUMMARY = "Wearable Technologies Conference 2016 demo image"

LICENSE := "MIT"

export IMAGE_BASENAME = "wtc-2016-headless-image"
