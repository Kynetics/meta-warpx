require recipes-core/images/core-image-base.bb
require warpx.inc

SUMMARY = "Warpx demo image"

LICENSE := "MIT"

export IMAGE_BASENAME = "warpx-headless-image"
